# Keil uVision project Wifi_Get_Test_V1.uvprojx, settings and files
target Wifi_Get_Test_V1 (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.pdsc
  output: Wifi_Get_Test_V1
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DTARGET_KSDK2_MCUS -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DFEATURE_STORAGE=1 -DTARGET_KPSDK_CODE -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_RELEASE -DTARGET_MCU_K64F --no_rtti -DFEATURE_CLIENT=1 -DARM_MATH_CM4 -Otime -DDEVICE_PORTINOUT=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -O3 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DFEATURE_IPV4=1 -DTARGET_KPSDK_MCUS -DTARGET_Freescale -DDEVICE_I2C=1 --preinclude=mbed_config.h -DDEVICE_PORTIN=1 -DDEVICE_LOWPOWERTIMER=1 -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -DFSL_RTOS_MBED --md -DTARGET_FRDM -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DDEVICE_TRNG=1 -DFEATURE_COMMON_PAL=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DMBED_BUILD_TIMESTAMP=1487949273.3 -DTARGET_K64F -DCPU_MK64FN1M0VMD12 -DDEVICE_STORAGE=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DFEATURE_IPV6=1 -D__MBED_CMSIS_RTOS_CM
  c include: .; easy-connect; easy-connect/esp8266-driver; easy-connect/esp8266-driver/ESP8266; easy-connect/esp8266-driver/ESP8266/ATParser; easy-connect/esp8266-driver/ESP8266/ATParser/BufferedSerial; easy-connect/esp8266-driver/ESP8266/ATParser/BufferedSerial/Buffer; simple-mbed-client; simple-mbed-client/pal; simple-mbed-client/pal/Source; simple-mbed-client/pal/Source/Port; simple-mbed-client/pal/Source/Port/Reference-Impl; simple-mbed-client/pal/Source/Port/Reference-Impl/mbedOS; simple-mbed-client/pal/Source/Port/Reference-Impl/mbedOS/RTOS; simple-mbed-client/pal/Source/Port/Reference-Impl/mbedOS/Networking; simple-mbed-client/pal/Source/Port/Platform-API; simple-mbed-client/pal/Source/PAL-Impl; simple-mbed-client/pal/Source/PAL-Impl/Services-API; simple-mbed-client/pal/Source/PAL-Impl/Modules; simple-mbed-client/pal/Source/PAL-Impl/Modules/RTOS; simple-mbed-client/pal/Source/PAL-Impl/Modules/Networking; simple-mbed-client/pal/Source/PAL-Impl/Modules/Update; simple-mbed-client/mbed-client; simple-mbed-client/mbed-client/source; simple-mbed-client/mbed-client/source/include; simple-mbed-client/mbed-client/mbed-client-classic; simple-mbed-client/mbed-client/mbed-client-classic/source; simple-mbed-client/mbed-client/mbed-client-classic/mbed-client-classic; simple-mbed-client/mbed-client/mbed-client-mbed-tls; simple-mbed-client/mbed-client/mbed-client-mbed-tls/source; simple-mbed-client/mbed-client/mbed-client-mbed-tls/mbed-client-mbedtls; simple-mbed-client/mbed-client/mbed-client; mbed-os/.; mbed-os/docs; mbed-os/features; mbed-os/features/frameworks; mbed-os/features/frameworks/greentea-client; mbed-os/features/frameworks/greentea-client/greentea-client; mbed-os/features/frameworks/greentea-client/source; mbed-os/features/frameworks/unity; mbed-os/features/frameworks/unity/source; mbed-os/features/frameworks/unity/unity; mbed-os/features/frameworks/utest; mbed-os/features/frameworks/utest/source; mbed-os/features/frameworks/utest/utest; mbed-os/features/mbedtls; mbed-os/features/mbedtls/importer; mbed-os/features/mbedtls/inc; mbed-os/features/mbedtls/inc/mbedtls; mbed-os/features/mbedtls/src; mbed-os/features/mbedtls/platform; mbed-os/features/mbedtls/platform/inc; mbed-os/features/mbedtls/platform/src; mbed-os/features/nanostack; mbed-os/features/storage; mbed-os/features/netsocket; mbed-os/cmsis; mbed-os/drivers; mbed-os/events; mbed-os/events/equeue; mbed-os/rtos; mbed-os/rtos/rtx; mbed-os/rtos/rtx/TARGET_CORTEX_M; mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7; mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM; mbed-os/hal; mbed-os/hal/storage_abstraction; mbed-os/platform; mbed-os/targets; mbed-os/targets/TARGET_Freescale; mbed-os/features/FEATURE_COMMON_PAL; mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c; mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/doxygen; mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/nsdl-c; mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source; mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libCoap; mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libCoap/src; mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libCoap/src/include; mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libNsdl; mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libNsdl/src; mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libNsdl/src/include; mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib; mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/mbed-client-randlib; mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/mbed-client-randlib/platform; mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/source; mbed-os/features/FEATURE_COMMON_PAL/mbed-trace; mbed-os/features/FEATURE_COMMON_PAL/mbed-trace/mbed-trace; mbed-os/features/FEATURE_COMMON_PAL/mbed-trace/source; mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos; mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/cs_nvm; mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/nvm; mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice; mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/mbed-client-libservice; mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/mbed-client-libservice/platform; mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source; mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/IPv6_fcf_lib; mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libBits; mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libList; mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libTrace; mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libTrace/scripts; mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libip6string; mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/nsdynmemLIB; mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/nvmHelper; mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop; mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/nanostack-event-loop; mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/nanostack-event-loop/platform; mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/source; mbed-os/features/FEATURE_LWIP; mbed-os/features/FEATURE_LWIP/lwip-interface; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth/arch; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth/arch/TARGET_Freescale; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys/arch; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/api; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv4; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv6; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/priv; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/polarssl; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif; mbed-os/features/storage/FEATURE_STORAGE; mbed-os/features/storage/FEATURE_STORAGE/cfstore; mbed-os/features/storage/FEATURE_STORAGE/cfstore/configuration-store; mbed-os/features/storage/FEATURE_STORAGE/cfstore/doc; mbed-os/features/storage/FEATURE_STORAGE/cfstore/doc/design; mbed-os/features/storage/FEATURE_STORAGE/cfstore/doc/design/pics; mbed-os/features/storage/FEATURE_STORAGE/cfstore/doc/design/umlet; mbed-os/features/storage/FEATURE_STORAGE/cfstore/doc/project; mbed-os/features/storage/FEATURE_STORAGE/cfstore/source; mbed-os/features/storage/FEATURE_STORAGE/flash-journal; mbed-os/features/storage/FEATURE_STORAGE/flash-journal/flash-journal-strategy-sequential; mbed-os/features/storage/FEATURE_STORAGE/storage-volume-manager; mbed-os/features/storage/FEATURE_STORAGE/storage-volume-manager/source; mbed-os/features/storage/FEATURE_STORAGE/storage-volume-manager/storage-volume-manager;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-DCPU_MK64FN1M0VMD12,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DFSL_RTOS_MBED
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: None
  group 
    ./: mbed_config.h config.h security.h main.cpp
  group configuration-store
    mbed-os/features/storage/FEATURE_STORAGE/cfstore/configuration-store/: configuration_store.h
  group Networking
    simple-mbed-client/pal/Source/PAL-Impl/Modules/Networking/: pal_network.c
    simple-mbed-client/pal/Source/Port/Reference-Impl/mbedOS/Networking/: pal_plat_network.cpp
  group cs_nvm
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/cs_nvm/: cs_nvm.c
  group rtos
    mbed-os/rtos/: Mail.h MemoryPool.h Mutex.h Queue.h RtosTimer.h Semaphore.h Thread.h rtos.h rtos_idle.h rtos_idle.c Mutex.cpp RtosTimer.cpp Semaphore.cpp Thread.cpp
  group cmsis
    mbed-os/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_caFunc.h core_caInstr.h core_ca_mmu.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
  group utest
    mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
    mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
  group nvmHelper
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/nvmHelper/: ns_nvm_helper.c
  group TARGET_Freescale
    mbed-os/targets/TARGET_Freescale/: mbed_rtx.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth/arch/TARGET_Freescale/: k64f_emac_config.h lwipopts_conf.h hardware_init_MK64F12.c k64f_emac.c hardware_init_MK66F18.c
  group mbed-client-mbedtls
    simple-mbed-client/mbed-client/mbed-client-mbed-tls/mbed-client-mbedtls/: m2mconnectionsecuritypimpl.h
  group nsdynmemLIB
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/nsdynmemLIB/: nsdynmemLIB.c
  group mbedtls
    mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h cmac.h config-no-entropy.h net_sockets.h platform_time.h ssl.h
  group api
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/api/: lwip_api_lib.c lwip_api_msg.c lwip_err.c lwip_netbuf.c lwip_netdb.c lwip_netifapi.c lwip_sockets.c lwip_tcpip.c
  group nanostack-event-loop
    mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/nanostack-event-loop/: eventOS_callback_timer.h eventOS_event.h eventOS_event_timer.h eventOS_scheduler.h
  group platform
    mbed-os/platform/: CThunk.h CallChain.h Callback.h CircularBuffer.h FunctionPointer.h PlatformMutex.h SingletonPtr.h Transaction.h critical.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h platform.h rtc_time.h semihost_api.h toolchain.h wait_api.h mbed_preprocessor.h mbed_assert.c mbed_board.c mbed_critical.c mbed_error.c mbed_interface.c mbed_mem_trace.c mbed_semihost_api.c mbed_wait_api_no_rtos.c mbed_stats.c CallChain.cpp mbed_alloc_wrappers.cpp mbed_rtc_time.cpp mbed_wait_api_rtos.cpp retarget.cpp
    mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/mbed-client-randlib/platform/: arm_hal_random.h
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/mbed-client-libservice/platform/: arm_hal_interrupt.h arm_hal_nvm.h
    mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/nanostack-event-loop/platform/: arm_hal_timer.h eventloop_config.h
  group equeue
    mbed-os/events/equeue/: equeue.h equeue_platform.h equeue.c equeue_posix.c equeue_mbed.cpp
  group mbed-client-randlib
    mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/mbed-client-randlib/: randLIB.h
  group Platform-API
    simple-mbed-client/pal/Source/Port/Platform-API/: pal_plat_rtos.h pal_plat_network.h
  group IPv6_fcf_lib
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/IPv6_fcf_lib/: ip_fsc.c
  group hal
    mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h emac_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_ticker_api.c mbed_us_ticker_api.c
  group netsocket
    mbed-os/features/netsocket/: CellularInterface.h EthInterface.h MeshInterface.h NetworkInterface.h NetworkStack.h Socket.h SocketAddress.h TCPServer.h TCPSocket.h UDPSocket.h WiFiAccessPoint.h WiFiInterface.h emac_stack_mem.h nsapi.h nsapi_dns.h nsapi_types.h NetworkInterface.cpp NetworkStack.cpp Socket.cpp SocketAddress.cpp TCPServer.cpp TCPSocket.cpp UDPSocket.cpp WiFiAccessPoint.cpp nsapi_dns.cpp
  group Buffer
    easy-connect/esp8266-driver/ESP8266/ATParser/BufferedSerial/Buffer/: MyBuffer.h MyBuffer.cpp
  group mbed-client-classic
    simple-mbed-client/mbed-client/mbed-client-classic/mbed-client-classic/: m2mconnectionhandlerpimpl.h m2mtimerpimpl.h
  group TARGET_CORTEX_M
    mbed-os/rtos/rtx/TARGET_CORTEX_M/: RTX_CM_lib.h RTX_Config.h cmsis_os.h rt_Event.h rt_HAL_CM.h rt_List.h rt_Mailbox.h rt_MemBox.h rt_Memory.h rt_Mutex.h rt_OsEventObserver.h rt_Robin.h rt_Semaphore.h rt_System.h rt_Task.h rt_Time.h rt_Timer.h rt_TypeDef.h HAL_CM.c RTX_Conf_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_OsEventObserver.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group source
    mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/source/: ns_timer.h timer_sys.h event.c ns_timer.c ns_timeout.c system_timer.c minar_hal_timer.cpp
    mbed-os/features/storage/FEATURE_STORAGE/cfstore/source/: cfstore_config.h cfstore_debug.h cfstore_fnmatch.h cfstore_list.h cfstore_test.h cfstore_utest.h cfstore_uvisor.h cfstore_svm.h cfstore_fnmatch.c cfstore_test.c configuration_store.c cfstore_svm.cpp
    mbed-os/features/frameworks/unity/source/: unity.c
    mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/source/: randLIB.c
    mbed-os/features/FEATURE_COMMON_PAL/mbed-trace/source/: mbed_trace.c
    simple-mbed-client/mbed-client/source/: m2mreporthandler.cpp m2mdevice.cpp m2mresource.cpp nsdlaccesshelper.cpp m2mbase.cpp m2mobjectinstance.cpp m2mserver.cpp m2mtlvdeserializer.cpp m2mstring.cpp m2mresourceinstance.cpp m2msecurity.cpp m2mnsdlinterface.cpp m2mobject.cpp m2mtlvserializer.cpp m2minterfacefactory.cpp m2mblockmessage.cpp m2minterfaceimpl.cpp m2mfirmware.cpp
    simple-mbed-client/mbed-client/mbed-client-classic/source/: m2mconnectionhandlerpimpl.cpp m2mtimer.cpp m2mconnectionhandler.cpp m2mtimerpimpl.cpp
    simple-mbed-client/mbed-client/mbed-client-mbed-tls/source/: m2mconnectionsecuritypimpl.cpp m2mconnectionsecurity.cpp
    mbed-os/features/frameworks/greentea-client/source/: test_env.cpp greentea_serial.cpp greentea_metrics.cpp
    mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_types.cpp utest_stack_trace.cpp
    mbed-os/features/storage/FEATURE_STORAGE/storage-volume-manager/source/: storage_volume.cpp storage_volume_manager.cpp
  group greentea-client
    mbed-os/features/frameworks/greentea-client/greentea-client/: test_env.h greentea_serial.h greentea_metrics.h
  group nsdl-c
    mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/nsdl-c/: sn_coap_header.h sn_coap_protocol.h sn_nsdl.h sn_nsdl_lib.h sn_config.h sn_nsdl_lib2.h
  group include
    simple-mbed-client/mbed-client/source/include/: m2mreporthandler.h smartpointer.h m2minterfaceimpl.h nsdlaccesshelper.h m2mtlvdeserializer.h m2mnsdlobserver.h m2mtlvserializer.h nsdllinker.h eventdata.h m2mnsdlinterface.h
    mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libCoap/src/include/: sn_coap_header_internal.h sn_coap_protocol_internal.h
    mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libNsdl/src/include/: sn_grs.h sn_grs2.h
  group unity
    mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
  group flash-journal-strategy-sequential
    mbed-os/features/storage/FEATURE_STORAGE/flash-journal/flash-journal-strategy-sequential/: flash_journal_private.h flash_journal_strategy_sequential.h support_funcs.h flash_journal_crc.h flash_journal_crc.c strategy.c support_funcs.c
  group ipv4
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv4/: lwip_autoip.c lwip_dhcp.c lwip_etharp.c lwip_icmp.c lwip_igmp.c lwip_ip4.c lwip_ip4_addr.c lwip_ip4_frag.c
  group ipv6
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv6/: lwip_dhcp6.c lwip_ethip6.c lwip_icmp6.c lwip_inet6.c lwip_ip6.c lwip_ip6_addr.c lwip_ip6_frag.c lwip_mld6.c lwip_nd6.c
  group inc
    mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
  group libTrace
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libTrace/: ns_trace.c
  group events
    mbed-os/events/: Event.h EventQueue.h mbed_events.h EventQueue.cpp
  group libip6string
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libip6string/: ip6tos.c stoip6.c
  group core
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/: lwip_def.c lwip_dns.c lwip_inet_chksum.c lwip_init.c lwip_ip.c lwip_mem.c lwip_memp.c lwip_netif.c lwip_pbuf.c lwip_raw.c lwip_stats.c lwip_sys.c lwip_tcp.c lwip_tcp_in.c lwip_tcp_out.c lwip_timeouts.c lwip_udp.c
  group nanostack-hal-mbed-cmsis-rtos
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/: arm_hal_interrupt_private.h ns_event_loop.h ns_hal_init.h arm_hal_interrupt.c arm_hal_random.c ns_event_loop.c ns_hal_init.c arm_hal_timer.cpp
  group ESP8266
    easy-connect/esp8266-driver/ESP8266/: ESP8266.h ESP8266.cpp
  group mbed-os
    mbed-os/: mbed.h
  group priv
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h tcp_priv.h tcpip_priv.h
  group easy-connect
    easy-connect/: easy-connect.h
  group libBits
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libBits/: common_functions.c
  group mbed-client-libservice
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/mbed-client-libservice/: common_functions.h ip6string.h ip_fsc.h ns_list.h ns_nvm_helper.h ns_trace.h ns_types.h nsdynmemLIB.h
  group mbed-trace
    mbed-os/features/FEATURE_COMMON_PAL/mbed-trace/mbed-trace/: mbed_trace.h
  group polarssl
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group storage-volume-manager
    mbed-os/features/storage/FEATURE_STORAGE/storage-volume-manager/storage-volume-manager/: storage_volume_manager.h
  group nvm
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/nvm/: nvm_ram.c
  group arch
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys/arch/: cc.h perf.h sys_arch.h lwip_checksum.c lwip_memcpy.c lwip_sys_arch.c
  group esp8266-driver
    easy-connect/esp8266-driver/: ESP8266Interface.h ESP8266Interface.cpp
  group src
    mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c cmac.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c net_sockets.c sha512.c ssl_cache.c
    mbed-os/features/mbedtls/platform/src/: mbed_trng.c
    mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libCoap/src/: sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
    mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libNsdl/src/: sn_grs.c sn_nsdl.c sn_grs2.c sn_nsdl2.c
  group PAL-Impl
    simple-mbed-client/pal/Source/PAL-Impl/: pal_init.c
  group BufferedSerial
    easy-connect/esp8266-driver/ESP8266/ATParser/BufferedSerial/: BufferedSerial.h BufferedPrint.c BufferedSerial.cpp
  group lwip
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
  group netif
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/: etharp.h lowpan6.h lowpan6_opts.h lwip_ethernet.h slipif.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/: lwip_ethernet.c lwip_ethernetif.c lwip_lowpan6.c
  group libList
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libList/: ns_list.c
  group RTOS
    simple-mbed-client/pal/Source/Port/Reference-Impl/mbedOS/RTOS/: pal_plat_rtos.c
    simple-mbed-client/pal/Source/PAL-Impl/Modules/RTOS/: pal_rtos.c
  group mbed-client
    simple-mbed-client/mbed-client/mbed-client/: m2mconnectionsecurity.h m2mconnectionhandler.h m2mtimerobserver.h m2mconnectionobserver.h m2mobjectinstance.h m2msecurity.h m2mvector.h m2mserver.h m2mstring.h m2mfirmware.h m2mobservationhandler.h functionpointer.h m2mconstants.h m2mreportobserver.h m2mdevice.h m2minterface.h m2mresourceinstance.h m2minterfacefactory.h m2mbase.h m2mresource.h m2mconfig.h m2minterfaceobserver.h m2mtimer.h m2mobject.h m2mblockmessage.h
  group storage_abstraction
    mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
  group Services-API
    simple-mbed-client/pal/Source/PAL-Impl/Services-API/: pal_errors.h pal.h pal_configuration.h pal_types.h pal_macros.h pal_rtos.h pal_network.h
  group flash-journal
    mbed-os/features/storage/FEATURE_STORAGE/flash-journal/: flash_journal.h
  group ATParser
    easy-connect/esp8266-driver/ESP8266/ATParser/: ATParser.h ATParser.cpp
  group ppp
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group TOOLCHAIN_ARM
    mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM/: SVC_Table.S HAL_CM4.c
  group lwip-interface
    mbed-os/features/FEATURE_LWIP/lwip-interface/: EthernetInterface.h eth_arch.h lwip_stack.h lwipopts.h emac_lwip.c lwip_stack.c EthernetInterface.cpp emac_stack_lwip.cpp
  group drivers
    mbed-os/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h AnalogIn.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp RawSerial.cpp SPI.cpp SPISlave.cpp Serial.cpp SerialBase.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp
  group simple-mbed-client
    simple-mbed-client/: simple-mbed-client.h mbedtls_mbed_client_config.h mbed_client_config.h mbed-client-wrapper.h
